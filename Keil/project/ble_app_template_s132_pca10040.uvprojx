# Keil uVision project ble_app_template_s132_pca10040.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 S132 NRF_LOG_USES_RTT=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0  ARM_MATH_CM4 __FPU_PRESENT=1
  c include: ..\source\config;..\sdk\components\ble\ble_advertising;..\sdk\components\ble\common;..\sdk\components\ble\device_manager;..\sdk\components\drivers_nrf\common;..\sdk\components\drivers_nrf\config;..\sdk\components\drivers_nrf\delay;..\sdk\components\drivers_nrf\gpiote;..\sdk\components\drivers_nrf\hal;..\sdk\components\drivers_nrf\pstorage;..\sdk\components\drivers_nrf\uart;..\sdk\components\libraries\button;..\sdk\components\libraries\experimental_section_vars;..\sdk\components\libraries\fstorage;..\sdk\components\libraries\fstorage\config;..\sdk\components\libraries\sensorsim;..\sdk\components\libraries\timer;..\sdk\components\libraries\trace;..\sdk\components\libraries\uart;..\sdk\components\libraries\util;..\sdk\components\softdevice\common\softdevice_handler;..\sdk\components\softdevice\s132\headers;..\sdk\components\softdevice\s132\headers\nrf52;..\sdk\components\toolchain;..\sdk\bsp;..\sdk\segger_rtt;..\source;..\source\config;..\source\algorithm;..\source\algorithm\HeartRate;..\source\algorithm\Kiss_FFT_Library;..\source\measure_test
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group Application
    ../source/: main.c CortexM_StackCheck.c wrapper.c
  group Dev_Startup
    ../sdk/components/toolchain/arm/: arm_startup_nrf52.s
    ../sdk/components/toolchain/: system_nrf52.c
  group Board Support
    ../sdk/bsp/: bsp.c bsp_btn_ble.c
  group nRF_BLE
    ../sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../sdk/components/ble/ble_advertising/: ble_advertising.c
    ../sdk/components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../sdk/components/libraries/uart/: app_uart.c
    ../sdk/components/drivers_nrf/delay/: nrf_delay.c
    ../sdk/components/drivers_nrf/common/: nrf_drv_common.c
    ../sdk/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../sdk/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../sdk/components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../sdk/components/libraries/button/: app_button.c
    ../sdk/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../sdk/components/libraries/timer/: app_timer.c
    ../sdk/components/libraries/trace/: app_trace.c
    ../sdk/components/libraries/fstorage/: fstorage.c
    ../sdk/components/libraries/uart/: retarget.c
    ../sdk/components/libraries/sensorsim/: sensorsim.c
  group nRF_Segger_RTT
    ../sdk/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../sdk/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group User_Algorithm
    ../../c/: step.c utils.c nonwalk_check.c nonwalk_model.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
